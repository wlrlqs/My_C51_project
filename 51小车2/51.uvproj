# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 chelun.c chelun.h RED.c RED.h HR_SC.h HR_SC.c main.c xj.txt xj.c bule.txt xj.h HCSR.c HCSR.h REG52.h
