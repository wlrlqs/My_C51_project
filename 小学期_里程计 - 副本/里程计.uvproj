# Keil uVision project 里程计.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: 里程计 +hex
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ./Application/: main.c UsartInit.c OLED12864.c motor.c
    ./: key_scan.c key_scan.h
  group RTOS
    ./RTOS/: Conf_tny.A51 RTX51TNY.LIB
