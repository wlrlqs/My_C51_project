# Keil uVision project 51小车.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51小车 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c pwm_out_moto.c pwm_out_moto.h car.h delay1s.c HC.c save.txt save2.txt steer.c save3.txt follow the trail.c buletooth.c
